require flutter-engine.inc

FLUTTER_CHANNEL = "beta"
FLUTTER_ENGINE = "release"
